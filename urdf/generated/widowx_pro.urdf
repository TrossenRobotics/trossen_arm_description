Commit message: update generated urdf for joint 5 y offset to zero

File: urdf/generated/widowx_pro.urdf (robot description, URDF)
Before this commit: robot widowx_pro, 14 links, 13 joints
Joints:
- joint joint_5: origin xyz=-0.012 0.001147 -0.048 rpy=0 0 0 -> xyz=-0.012 0.0 -0.048 rpy=0 0 0
